KCS_DEVICE = "ipmi-kcs1 ipmi-kcs2 ipmi-kcs3 ipmi-kcs4"
SYSTEMD_SERVICE_${PN} = " ${PN}@ipmi-kcs1.service ${PN}@ipmi-kcs2.service ${PN}@ipmi-kcs3.service ${PN}@ipmi-kcs4.service "

