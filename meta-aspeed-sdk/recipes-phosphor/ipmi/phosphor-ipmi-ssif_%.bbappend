PROVIDES_remove = "virtual/obmc-host-ipmi-hw"
RPROVIDES_${PN}_remove = "virtual-obmc-host-ipmi-hw"
RRECOMMENDS_${PN}_remove = "phosphor-ipmi-host"
