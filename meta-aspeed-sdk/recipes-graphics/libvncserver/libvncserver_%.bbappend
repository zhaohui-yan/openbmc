PACKAGECONFIG:append = " pthread "
