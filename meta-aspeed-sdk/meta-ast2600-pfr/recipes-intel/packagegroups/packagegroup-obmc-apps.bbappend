RDEPENDS:${PN}-settings = "settings"

