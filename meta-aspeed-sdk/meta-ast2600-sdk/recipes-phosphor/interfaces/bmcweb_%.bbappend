EXTRA_OEMESON_append_ast-mmc = " \
    -Dredfish-dbus-log=enabled \
    -Dhttp-body-limit=128 \
    "
