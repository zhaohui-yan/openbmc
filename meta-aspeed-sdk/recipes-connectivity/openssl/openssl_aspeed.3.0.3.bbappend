FILESEXTRAPATHS:prepend := "${THISDIR}/openssl-aspeed.3.0.3:"
# Mark the following setting to use 3.0.3
DEFAULT_PREFERENCE = "-1"
