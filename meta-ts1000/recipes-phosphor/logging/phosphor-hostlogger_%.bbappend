# FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# DEFAULT_INSTANCE = "ttyS2"

# SRC_URI:append = " \
# 	file://ttyS2.conf \
# 	"
# 20250626: use default configuration in meta-phosphor layer meta-phosphor/recipes-phosphor/sel-logger/phosphor-sel-logger_git.bb
