# Sync to the latest x86-power-control. We can remove it after rebasing OpenBMC.
SRCREV = "05e8ea8e3c834f2bd029647930dd8c139486bada"
