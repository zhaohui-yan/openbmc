
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
           file://0001-TS1000-Fix-a-crash-and-support-for-6.7-kernel.patch \
           "
